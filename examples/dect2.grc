options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: auto_scroll
  id: variable_qtgui_msgcheckbox
  parameters:
    gui_hint: '[0,2]'
    initPressed: 'True'
    label: Auto Scroll
    outputmsgname: auto_scroll
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'True'
  states: {}
- name: baseband_sampling_rate
  id: variable
  parameters:
    value: 100000000/32
  states: {}
- name: dect_channel_bandwidth
  id: variable
  parameters:
    value: 1.728e6
  states: {}
- name: dect_occupied_bandwidth
  id: variable
  parameters:
    value: 1.2*dect_symbol_rate
  states: {}
- name: dect_symbol_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: part_id
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,1]'
    label: Select Part
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "10", "11", "12", "13", "14", "15", "16", "17", "18", "19", "20","21","22","23","24","25","26","27","28","29","30","31","32"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32]'
    type: int
    value: '0'
  states: {}
- name: resample_ratio
  id: variable
  parameters:
    value: int((3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0)
  states: {}
- name: resampler_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)
  states: {}
- name: rx_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,0]'
    label: Carrier Number
    labels: '["0", "1", "2", "3", "4", "5", "6", "7", "8", "9", "10", "11", "12", "13", "14", "15", "16", "17", "18", "19", "20","21","22","23","24","25","26","27","28","29","30","31","32"]'
    num_opts: '0'
    options: '[1897344000, 1895616000, 1893888000, 1892160000, 1890432000, 1888704000, 1886876000, 1885248000, 1883520000, 1881792000, 1899072000, 1900800000, 1902528000, 1904256000, 1905984000, 1907712000, 1909440, 1911168000, 1912896000, 1914624000, 1916352000, 1918080000, 1919808000, 1921536000, 1923264000, 1924992000, 1926720000, 1928448000, 1930176000,  1931904000, 1933632000, 1935360000, 1937088000]'
    type: real
    value: '1897344000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0,0
    samp_rate: '48000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: console_0
  id: console
  parameters:
    auto_scroll: 'True'
  states: {}
- name: dect2_packet_decoder_0
  id: dect2_packet_decoder
  parameters:
    rx_id: part_id
  states: {}
- name: dect2_packet_receiver_0
  id: dect2_packet_receiver
  parameters: {}
  states: {}
- name: dect2_phase_diff_0
  id: dect2_phase_diff
  parameters: {}
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resample_ratio
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '3'
    taps: resampler_filter_taps
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: rx_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    samp_rate: '3125000'
    sync: none
    type: fc32
  states: {}
- name: vocoder_g721_decode_bs_0
  id: vocoder_g721_decode_bs
  parameters: {}
  states: {}

connections:
- [auto_scroll, state, console_0, config]
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [dect2_packet_decoder_0, '0', vocoder_g721_decode_bs_0, '0']
- [dect2_packet_decoder_0, log_out, console_0, in]
- [dect2_packet_receiver_0, '0', dect2_packet_decoder_0, '0']
- [dect2_packet_receiver_0, rcvr_msg_out, dect2_packet_decoder_0, rcvr_msg_in]
- [dect2_phase_diff_0, '0', dect2_packet_receiver_0, '0']
- [mmse_resampler_xx_0, '0', dect2_phase_diff_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', mmse_resampler_xx_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_1, '0']
- [vocoder_g721_decode_bs_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
